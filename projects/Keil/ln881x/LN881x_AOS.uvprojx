# Keil uVision project LN881x_AOS.uvprojx, settings and files
target ln881x (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LN8810 LightningSemi
  pack: Keil.LN88xx_DFP.1.0.1
  cpu: CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LN881x_AOS
  AfterMake: python ..\..\..\platform\mcu\ln88xx\tools\user_cmd\after_build_soc.py chip_family=LN881x cmd=flashimage project=LN881x_AOS output=flashimage.bin release=1 crp_enable=0 app_version=10 hw_version=0
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LN881x, ARM_MATH_CM4, BUILD_BIN, AOS_NO_WIFI, STDIO_UART=0, OSAL_RHINO, AOS_HAL,  AOS_COMP_RHINO, AOS_COMP_DEBUG, AOS_LOOP, WITH_LWIP, CONFIG_NET_LWIP, NET_WITH_WIFI, AOS_NETMGR, AOS_COMP_ULOG, __BSD_VISIBLE, AOS_COMP_VFS, AOS_COMP_KV
  c misc: -DMCU_FAMILY='\"mcu_ln88xx'\" -DSYSINFO_PRODUCT_MODEL='\"ALI_AOS_LN881X'\" -DSYSINFO_DEVICE_NAME='\"LN881X'\"
  c include: ..\..\..\include;..\..\..\kernel\init\include;..\..\..\kernel\debug;..\..\..\kernel\debug\include;..\..\..\kernel\rhino\include;..\..\..\platform\arch\arm\armv7m\include;..\..\..\platform\arch\arm\armv7m\common\include;..\..\..\board\ln8810evb\config;..\..\..\utility\libc\compilers\armlibc;..\..\..\platform\mcu\ln88xx\include\cpu\ARM_CM4F\ln88xx;..\..\..\platform\mcu\ln88xx\include\cpu\ARM_CM4F\CMSIS_5.3.0;..\..\..\platform\mcu\ln88xx\include;..\..\..\platform\mcu\ln88xx\include\net\lwip-2.0.3;..\..\..\platform\mcu\ln88xx\include\driver_ln881x;..\..\..\platform\mcu\ln88xx\src\driver_ln881x\ll\include;..\..\..\platform\mcu\ln88xx\include\kernel;..\..\..\platform\mcu\ln88xx\include\kernel\AliOS_Adapter;..\..\..\platform\mcu\ln88xx\test\certificate_test\cutest;..\..\..\network\lwip\include;..\..\..\include\network;..\..\..\include\network\bluetooth\breeze\api;..\..\..\include\network\bluetooth\breeze\core\include;..\..\..\include\network\bluetooth\bt_host\bt_common\include;..\..\..\include\network\bluetooth\bt_host\bt_common\port\include;..\..\..\include\network\bluetooth\bt_host\bt_common\tinycrypt\include;..\..\..\include\network\bluetooth\bt_host\include;..\..\..\include\network\bluetooth\bt_host\include\drivers;..\..\..\include\network\bluetooth\bt_host\profile;..\..\..\include\network\bluetooth\bt_mesh\inc;..\..\..\include\network\bluetooth\tmall_model;..\..\..\include\network\coap;..\..\..\include\network\http;..\..\..\include\network\lwm2m;..\..\..\include\network\umesh;..\..\..\include\network\nal\athost;..\..\..\include\network\nal\atparser;..\..\..\include\network\nal\sal;..\..\..\include\network\lwip;..\..\..\include\network\netmgr;..\..\..\include\network\yloop;..\..\..\kernel\cli\include;..\..\..\network\yloop\include;..\..\..\network\yloop\hal;..\..\..\3rdparty\experimental\fs\fatfs\include;..\..\..\3rdparty\experimental\fs\fatfs\ff\include;..\..\..\kernel\fs\vfs\include;..\..\..\middleware\uagent\ulog\include;..\..\..\kernel\fs\kv\include;..\..\..\kernel\lib\rbtree\include;..\..\..\platform\mcu\ln88xx\include\libc
  asm misc: --cpreproc
  asm include: ..\..\..\board\ln8810evb\config
  library: MicroLIB
  scatter file: ..\..\..\board\ln8810evb\ln881x.sct
  group helloworld
    ../../../app/example/helloworld/: helloworld.c
  group board_ln8810evb
    ../../../board/ln8810evb/config/: k_config.c partition_conf.c
    ../../../board/ln8810evb/startup/: board.c startup.c startup_keil.S
  group rhino
    ../../../kernel/rhino/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_spin_lock.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group osal_aos
    ../../../osal/aos/: cli.c common.c kv.c rhino.c vfs.c
  group arch_armv7m
    ../../../platform/arch/arm/armv7m/armcc/m4/: port_s.S
    ../../../platform/arch/arm/armv7m/common/: backtrace.c panic_c.c panic_mpu.c port_c.c
  group mcu_ln88xx
    ../../../platform/mcu/ln88xx/src/cpu/ARM_CM4F/ln88xx/: system_ln88xx.c
    ../../../platform/mcu/ln88xx/src/utils/debug/: art_assert.c log.c
    ../../../platform/mcu/ln88xx/src/utils/: wrap_stdio.c
    ../../../platform/mcu/ln88xx/src/net/lwip/: checksum.c memcpy.c
  group mcu_ln88xx_aos_hal
    ../../../platform/mcu/ln88xx/hal/: hal.c hal_flash.c hal_sd.c hal_uart.c
  group mcu_ln88xx_drv_hal
    ../../../platform/mcu/ln88xx/src/driver_ln881x/hal/: hal_syscon.c qspi.c hal_uart.c hal_dma.c hal_common.c flash.c cache.c
  group mcu_ln88xx_drv_ll
    ../../../platform/mcu/ln88xx/src/driver_ln881x/ll/: ll_cache.c ll_dma.c ll_qspi.c ll_uart.c ll_syscon.c
  group mcu_ln88xx_aos_adapter
    ../../../platform/mcu/ln88xx/src/kernel/AliOS_Adapter/: alios_mutex.c alios_queue.c alios_semaphore.c alios_thread.c alios_timer.c
  group libc
    ../../../utility/libc/compilers/armlibc/: armcc_libc.c
  group kernel_init
    ../../../kernel/init/: aos_init.c
  group netmgr
    ../../../network/netmgr/hal/: wifi.c
    ../../../network/netmgr/src/: netmgr.c netmgr_wifi.c
  group lwip
    ../../../network/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../network/lwip/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c pkt_print.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../network/lwip/netif/: ethernet.c slipif.c
    ../../../network/lwip/port/: sys_arch.c
    ../../../network/lwip/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../network/lwip/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group cli
    ../../../kernel/cli/: cli.c cli_adapt.c cli_cpuusage.c cli_default_command.c cli_dumpsys.c
  group yloop
    ../../../network/yloop/hal/: loop_hal_alios.c
    ../../../network/yloop/src/: device.c local_event.c select.c workqueue.c yloop.c
  group fatfs
    ../../../3rdparty/experimental/fs/fatfs/: diskio.c fatfs_vfs.c
    ../../../3rdparty/experimental/fs/fatfs/ff/: ff.c ffunicode.c
  group debug
    ../../../kernel/debug/: debug_backtrace.c debug_cpuusage.c debug_infoget.c debug_overview.c debug_panic.c
  group vfs
    ../../../kernel/fs/vfs/: vfs.c vfs_adapt.c vfs_file.c vfs_inode.c
  group ulog
    ../../../middleware/uagent/ulog/: ulog.c ulog_init.c ulog_utility.c
  group kv
    ../../../kernel/fs/kv/: kv.c kv_adapt.c kv_cli.c
  group lib_rbtree
    ../../../kernel/lib/rbtree/: rbtree.c
